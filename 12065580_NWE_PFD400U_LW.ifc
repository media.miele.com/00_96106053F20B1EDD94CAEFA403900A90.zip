Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-10-19T10:31:57
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 19 10:31:57 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\3fcf3566-8c54-45b0-9031-af7e6610caba\02810efe-2d21-4025-9bc7-50c6f308d7e7\ifc * Database version: 5507 * Database creation date: Wed Oct 19 10:31:56 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 19 10:31:56 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 19 10:31:56 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12065580_NWE_PFD400U_LW:61040020_NWE_12065580_PFD400U_LW, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 61040020_NWE_12065580_PFD400U_LW
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 61040020_NWE_12065580_PFD400U_LW
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_BRWS, z_Miele_Design_Glass Black, z_Miele_Design_GRGR, z_Miele_Connection_Electric, z_Miele_Connection_Water_IN, z_Miele_Connection_Water_OUT, z_Miele_Connection_Liquid Detergent, z_Miele_Connection_Connection_Modul
Pset_BuildingElementProxyCommon - sets with these values: 2
